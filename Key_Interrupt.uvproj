# Keil uVision project Key_Interrupt.uvproj, settings and files
target KEY_Interrupt (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: test +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS\startup;.\CMSIS;.\USER;.\APP;.\SYSTEM;.\FWlib\inc;.\FWlib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group USER
    ./USER/: main.c stm32f10x_it.c
  group APP
    ./APP/: LED.c
  group SYSTEM
    ./SYSTEM/: Delay.c sys.c usart.c
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
